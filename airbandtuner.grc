options:
  parameters:
    author: JoeTester1965
    copyright: MIT license
    generate_options: qt_gui
    id: airbandtuner
    output_language: python
    title: AirBandTuner
  states: {}

blocks:
- name: AudioStreamIP
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,0
    type: string
    value: 127.0.0.1
  states: {}
- name: AudioStreamPort
  id: variable_qtgui_entry
  parameters:
    gui_hint: 3,1
    type: int
    value: '7355'
  states: {}
- name: audio_gain
  id: variable
  parameters:
    value: '126'
  states: {}
- name: carrier_squelch
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0
    rangeType: int
    start: '-90'
    step: '1'
    stop: '-20'
    value: '-40'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '40'
  states: {}
- name: fft_resolution
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1
    start: '0'
    step: '1'
    stop: '49'
    value: '35'
  states: {}
- name: hold_seconds
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1
    rangeType: int
    start: '1'
    step: '1'
    stop: '30'
    value: '3'
  states: {}
- name: ppm
  id: variable_qtgui_entry
  parameters:
    gui_hint: 4,1
    type: int
    value: '0'
  states: {}
- name: samp_rate
  id: variable_qtgui_entry
  parameters:
    gui_hint: 4,0
    type: int
    value: '1920000'
  states: {}
- name: tuning_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    start: 108e6
    step: '1000000'
    stop: 137e6
    value: 135e6
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '4000'
    audio_stop: '4500'
    chan_rate: samp_rate/decimation
  states: {}
- name: analog_feedforward_agc_cc_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: '1024'
    reference: '1.0'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: carrier_squelch
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_endian_swap_0
  id: blocks_endian_swap
  parameters:
    type: s16
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: audio_gain
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: decimation
    samp_rate: samp_rate
    taps: ' firdes.low_pass(1,samp_rate,samp_rate/decimation/8,1000)'
    type: ccc
  states: {}
- name: logpwrfft_x_0
  id: logpwrfft_x
  parameters:
    average: 'False'
    avg_alpha: '1.0'
    fft_size: fft_resolution
    frame_rate: '10'
    ref_scale: '2'
    sample_rate: samp_rate
    shift: 'True'
    type: complex
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: AudioStreamIP
    header: '0'
    payloadsize: '1472'
    port: AudioStreamPort
    send_eof: 'False'
    type: short
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: audiotunerclient.py
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: audiotunerclient.py
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    name: Radio spectrum
    ref_level: carrier_squelch
    vlen: fft_resolution
    x_axis_label: Frequency
    x_start: tuning_freq - (samp_rate/2)
    x_step: samp_rate/fft_resolution
    x_units: Hz
    y_axis_label: Power
    y_units: dB
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: tuning_freq
    dev_args: remote=192.168.1.50,driver=remote,remote:timeout=100000,remote:driver=rtlsdr,rtl=0
    freq_correction: ppm
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '50240'
  states: {}
- name: zeromq_pub_sink_1
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:50242
    timeout: '100'
    type: float
    vlen: fft_resolution
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:50241
    timeout: '100'
  states: {}

connections:
- [analog_am_demod_cf_0, '0', audio_sink_0, '0']
- [analog_am_demod_cf_0, '0', blocks_float_to_short_0, '0']
- [analog_feedforward_agc_cc_0, '0', analog_am_demod_cf_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_feedforward_agc_cc_0, '0']
- [blocks_endian_swap_0, '0', network_udp_sink_0, '0']
- [blocks_float_to_short_0, '0', blocks_endian_swap_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_pwr_squelch_xx_0, '0']
- [logpwrfft_x_0, '0', qtgui_vector_sink_f_0, '0']
- [logpwrfft_x_0, '0', zeromq_pub_sink_1, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_rtlsdr_source_0, '0', logpwrfft_x_0, '0']
- [zeromq_pull_msg_source_0, out, freq_xlating_fir_filter_xxx_0, freq]

metadata:
  file_format: 1
